# Autodesk Inventor part: D151_1in
## iProperties
Created: 2011-03
Part Number: D151_1in
Document SubType Name: Modeling
Designer: D Cole
Density: 1 g/cm^3
Author: D Cole
